require xbmc.inc
# SRCREV="9bffa6ce6bfd1b075b14f57c2f7855cc4a45541c"
# SRCREV="8346b7001cafe08aa2fe979eb78723ce5d02b781"
# SRCREV="abf013a59d5101e8d21d89ed3be04d31a894af40"
# kodi SRCREV="62d01f6b401af69d6f2be039ebefc6e143e3486e"
SRCREV="bf4eb6de87ef1bf2973b4ab325d0f93b30f3d591"

do_qa_configure(){
 echo "disabled for now"
}

PR = "${INC_PR}.1"

