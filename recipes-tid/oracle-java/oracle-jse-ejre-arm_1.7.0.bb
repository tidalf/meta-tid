PV_UPDATE = "60"

require oracle-jse-ejre.inc

SRC_URI = "http://ematome.com/ejre-7u60-fcs-b19-linux-arm-vfp-hflt-client_headful-07_may_2014.tar.gz"
SRC_URI[md5sum] = "35a02cd482e901cf8044ead040d54a5e"
SRC_URI[sha256sum] = "1d5e870e49bb493fe03b2b2f2cb7dcce49315f988a820d6f2f650ad360ff9986"

