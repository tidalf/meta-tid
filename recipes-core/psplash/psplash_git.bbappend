FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"

# SRC_URI += "file://psplash-optimize-hp2-splash-screen.patch"
SRC_URI += "file://black.patch"

